options:
  parameters:
    author: Art3m1sF0wl
    generate_options: qt_gui
    id: QPSK_BPSK_toggle
    output_language: python
    title: QPSK_BPSK_toggle
  states: {}

blocks:
- name: RX_rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '40'
  states: {}
- name: RXfrequency
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '145400000'
  states: {}
- name: TX_rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '40'
  states: {}
- name: TXfrequency
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '145400000'
  states: {}
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: access_key_0
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: excess_bw_0
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_slider
  id: variable_qtgui_range
  parameters:
    start: '-1000000'
    step: '1000'
    stop: '1000000'
    value: '0'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: hdr_format_0
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: modulation_toggle
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    label: pressedBPSKred releasedQPSKgreen RX
    pressBackgroundColor: red
    pressed: '1'
    relBackgroundColor: green
    released: '0'
    type: int
    value: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: offset_freq
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: order
  id: variable
  parameters:
    value: '4'
  states: {}
- name: order_0
  id: variable
  parameters:
    value: '2'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: phase_bw_0
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.040'
  states: {}
- name: rs_ratio_0
  id: variable
  parameters:
    value: '1.040'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: sdr_samp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sps_0
  id: variable
  parameters:
    value: '2'
  states: {}
- name: sps_0_0
  id: variable
  parameters:
    value: '2'
  states: {}
- name: sps_1
  id: variable
  parameters:
    value: '2'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: thresh_0
  id: variable
  parameters:
    value: '1'
  states: {}
- name: transmit_button
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    label: TX
    pressBackgroundColor: red
    pressed: '1'
    released: '0'
    type: int
    value: '1'
  states: {}
- name: usrp_rate_1
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: sps
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_adaptive_algorithm_0_0
  id: variable_adaptive_algorithm
  parameters:
    cons: bpsk
    modulus: sps
    step_size: '.0001'
    type: cma
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-offset_freq'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/art3m1sf0wl/program/TRX_test/c3/LRPT_working/rx_data.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/art3m1sf0wl/program/TRX_test/c3/test_out.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/art3m1sf0wl/program/TRX_test/c3/LRPT_working/tx_data.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/art3m1sf0wl/program/TRX_test/c3/test.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(modulation_toggle)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: int(modulation_toggle)
    type: complex
  states: {}
- name: blocks_selector_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(transmit_button)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '252'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '252'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0_2
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: order
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: order
    w: phase_bw
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_1
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '1'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: digital_protocol_formatter_bb_0_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      The CMA equalizer has been
      replaced by a Linear Equalizer
      and an Adaptive Algorithm for
      version 3.9
    note: CMA equalizer replaced
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      The CMA equalizer has been
      replaced by a Linear Equalizer
      and an Adaptive Algorithm for
      version 3.9
    note: CMA equalizer replaced
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    ant0: TX1
    args: '"bladerf=0,nchan=1,buffers=48,transfers=24,agc_mode=manual,biastee=1"'
    bb_gain0: '20'
    freq0: TXfrequency+freq_slider-offset_freq
    gain0: TX_rf_gain
    if_gain0: '20'
    num_mboards: '2'
    sample_rate: sdr_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    ant0: RX1
    args: '"bladerf=0,nchan=1,buffers=48,transfers=24,agc_mode=manual"'
    bb_gain0: '20'
    freq0: RXfrequency+freq_slider
    gain0: RX_rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: sdr_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"5_uscente da costal loop"'
    size: '1024'
    type: complex
    ymax: '1'
    ymin: '-1'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: '"1_source"'
    size: '1024'
    type: complex
    ymax: '1'
    ymin: '-1'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"2_uscente da sink_frac_reampler"'
    size: '1024'
    type: complex
    ymax: '1'
    ymin: '-1'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"3_uscente da symbol sink"'
    size: '1024'
    type: complex
    ymax: '1'
    ymin: '-1'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"4_uscente da lin equalizer"'
    size: '1024'
    type: complex
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_const_sink_x_0_0_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"4_uscente da lin equalizer"'
    size: '1024'
    type: complex
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_const_sink_x_0_0_0_0_1
  id: qtgui_const_sink_x
  parameters:
    name: '"3_uscente da symbol sink"'
    size: '1024'
    type: complex
    ymax: '1'
    ymin: '-1'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0_1
  id: qtgui_const_sink_x
  parameters:
    name: '"2_uscente da sink_frac_reampler"'
    size: '1024'
    type: complex
    ymax: '1'
    ymin: '-1'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    name: '"5_uscente da costal loop"'
    size: '1024'
    type: complex
    ymax: '1'
    ymin: '-1'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Mod Out QPSK"'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sdr_samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Time Sgn. OUT"'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Time Sgn. OUT"'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sdr_samp_rate
    fc: '415300000'
    fftsize: '1024'
    name: '"RX Waterfall"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_2
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: rx_bpsk1
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: tx_bpsk1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx2
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: rx_bpsk2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: rx_bpsk1
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: tx_bpsk1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx2
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: rx_bpsk2
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', zeromq_pub_sink_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0_1, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0_2, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_null_source_0, '0', blocks_selector_2, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_crc32_bb_0_0, '0']
- [blocks_selector_0, '0', blocks_selector_2, '1']
- [blocks_selector_1, '0', rational_resampler_xxx_0_0, '0']
- [blocks_selector_1, '1', rational_resampler_xxx_0_1, '0']
- [blocks_selector_2, '0', blocks_multiply_xx_0, '1']
- [blocks_selector_2, '0', blocks_multiply_xx_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_constellation_modulator_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_crc32_bb_0_1, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle_0_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle_0_0_0, '0', virtual_sink_0_0_0, '0']
- [blocks_throttle_0_1, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_throttle_0_1_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_throttle_0_2, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_1, '0']
- [digital_constellation_decoder_cb_0_0, '0', virtual_sink_1_0, '0']
- [digital_constellation_modulator_0, '0', virtual_sink_0, '0']
- [digital_constellation_modulator_0_0, '0', virtual_sink_0_1, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_1, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_0_0, '0']
- [digital_crc32_bb_0_1, '0', blocks_tagged_stream_mux_0_0, '1']
- [digital_crc32_bb_0_1, '0', digital_protocol_formatter_bb_0_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_0_0_0_0_0, '0']
- [digital_linear_equalizer_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_linear_equalizer_0_0, '0', qtgui_const_sink_x_0_0_0_0_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_0_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_protocol_formatter_bb_0_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0_0_0_1, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_const_sink_x_0_0_0_0, '0']
- [osmosdr_source_1, '0', blocks_selector_1, '0']
- [osmosdr_source_1, '0', qtgui_sink_x_0, '0']
- [osmosdr_source_1, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_selector_0, '1']
- [rational_resampler_xxx_0_0, '0', virtual_sink_0_0, '0']
- [rational_resampler_xxx_0_1, '0', virtual_sink_0_0_0, '0']
- [rational_resampler_xxx_0_2, '0', blocks_selector_0, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', blocks_throttle_0, '0']
- [virtual_source_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [virtual_source_0_0_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [virtual_source_0_1, '0', blocks_throttle_0_2, '0']
- [virtual_source_1, '0', digital_diff_decoder_bb_0, '0']
- [virtual_source_1_0, '0', digital_diff_decoder_bb_0_0, '0']
- [zeromq_sub_source_0, '0', blocks_selector_1, '0']
- [zeromq_sub_source_0, '0', qtgui_sink_x_0, '0']
- [zeromq_sub_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
