options:
  parameters:
    author: art3m1sf0wl
    generate_options: qt_gui
    id: test_9_merge_RTX
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: RX_rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '50'
  states: {}
- name: TX_rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '22'
  states: {}
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_slide
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: 1e3
    stop: 1e6
    value: '0'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: order
  id: variable
  parameters:
    value: '4'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.040'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: sdr_samp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sps_0
  id: variable
  parameters:
    value: '2'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: usrp_rate_0
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: sps
    step_size: '.0001'
    type: cma
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/ccc_gs/Scaricati/c3/qpsk/resultRX.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/art3m1sf0wl/program/TRX_test/test.txt
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(562,(105,115,32,115,105,109,112,108,121,32,100,117,109,109,121,32,116,101,120,116,32,111,102,32,116,104,101,32,112,114,105,110,116,105,110,103,32,97,110,100,32,116,121,112,101,115,101,116,116,105,110,103,32,105,110,100,117,115,116,114,121,46,32,76,111,114,101,109,32,73,112,115,117,109,32,104,97,115,32,98,101,101,110,32,116,104,101,32,105,110,100,117,115,116,114,121,39,115,32,115,116,97,110,100,97,114,100,32,100,117,109,109,121,32,116,101,120,116,32,101,118,101,114,32,115,105,110,99,101,32,116,104,101,32,49,53,48,48,115,44,32,119,104,101,110,32,97,110,32,117,110,107,110,111,119,110,32,112,114,105,110,116,101,114,32,116,111,111,107,32,97,32,103,97,108,108,101,121,32,111,102,32,116,121,112,101,32,97,110,100,32,115,99,114,97,109,98,108,101,100,32,105,116,32,116,111,32,109,97,107,101,32,97,32,116,121,112,101,32,115,112,101,99,105,109,101,110,32,98,111,111,107,46,32,73,116,32,104,97,115,32,115,117,114,118,105,118,101,100,32,110,111,116,32,111,110,108,121,32,102,105,118,101,32,99,101,110,116,117,114,105,101,115,44,32,98,117,116,32,97,108,115,111,32,116,104,101,32,108,101,97,112,32,105,110,116,111,32,101,108,101,99,116,114,111,110,105,99,32,116,121,112,101,115,101,116,116,105,110,103,44,32,114,101,109,97,105,110,105,110,103,32,101,115,115,101,110,116,105,97,108,108,121,32,117,110,99,104,97,110,103,101,100,46,32,73,116,32,119,97,115,32,112,111,112,117,108,97,114,105,115,101,100,32,105,110,32,116,104,101,32,49,57,54,48,115,32,119,105,116,104,32,116,104,101,32,114,101,108,101,97,115,101,32,111,102,32,76,101,116,114,97,115,101,116,32,115,104,101,101,116,115,32,99,111,110,116,97,105,110,105,110,103,32,76,111,114,101,109,32,73,112,115,117,109,32,112,97,115,115,97,103,101,115,44,32,97,110,100,32,109,111,114,101,32,114,101,99,101,110,116,108,121,32,119,105,116,104,32,100,101,115,107,116,111,112,32,112,117,98,108,105,115,104,105,110,103,32,115,111,102,116,119,97,114,101,32,108,105,107,101,32,65,108,100,117,115,32,80,97,103,101,77,97,107,101,114,32,105,110,99,108,117,100,105,110,103,32,118,101,114,115,105,111,110,115,32,111,102,32,76,111,114,101,109,32,73,112,115,117,109,10)))
    period: '500'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '252'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: order
    w: phase_bw
  states: {}
- name: digital_crc32_async_bb_1
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {state: disabled}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: cc
  states: {state: disabled}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """Packet Format"""

          def __init__(self):
              gr.sync_block.__init__(self,
                  name = "Packet Format",
                  in_sig = None,
                  out_sig = None)
              self.message_port_register_in(pmt.intern('PDU_in'))
              self.message_port_register_out(pmt.intern('PDU_out'))
              self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)

          def handle_msg(self, msg):
              inMsg = pmt.to_python (msg)
              pld = inMsg[1]
              # print (pld)
              mLen = len(pld)
              # print (mLen)
              if (mLen > 0):
                  char_list = [85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,225,90,232,147]
                  char_list.append (mLen >> 8)
                  char_list.append (mLen & 255)
                  char_list.append (mLen >> 8)
                  char_list.append (mLen & 255)
                  char_list.extend (pld)
                  # print (char_list)
                  out_len = len(char_list)
                  # print (out_len)
                  self.message_port_pub(pmt.intern('PDU_out'), pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(out_len,(char_list))))
  states: {state: disabled}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1.0/((usrp_rate/samp_rate)*rs_ratio)
    type: complex
  states: {state: disabled}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: ((usrp_rate/samp_rate)*rs_ratio)
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      The CMA equalizer has been
      replaced by a Linear Equalizer
      and an Adaptive Algorithm for
      version 3.9
    note: CMA equalizer replaced
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 415.4e6+freq_slide
    gain0: TX_rf_gain
    if_gain0: '20'
    sample_rate: samp_rate_0
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: '"bladerf=0,nchan=1,buffers=48,transfers=24,agc_mode=manual"'
    bb_gain0: '20'
    freq0: 143.4e6+freq_slide
    gain0: RX_rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate_0
    sync: sync
    type: fc32
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"5_uscente da costal loop"'
    size: '1024'
    type: complex
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: '"1_source"'
    size: '1024'
    type: complex
    ymax: '1'
    ymin: '-1'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"2_uscente da sink_frac_reampler"'
    size: '1024'
    type: complex
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"3_uscente da symbol sink"'
    size: '1024'
    type: complex
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_const_sink_x_0_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"4_uscente da lin equalizer"'
    size: '1024'
    type: complex
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Mod Out QPSK"'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Time Sgn. OUT"'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sdr_samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX Waterfall"'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx1
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx1
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx2
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0_1, '0']
- [blocks_message_strobe_0, strobe, digital_crc32_async_bb_1, in]
- [blocks_multiply_const_vxx_0, '0', mmse_resampler_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle_0_1, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_1, '0']
- [digital_constellation_modulator_0, '0', virtual_sink_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc32_async_bb_1, out, epy_block_0, PDU_in]
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_0_0_0_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_const_sink_x_0_0_0_0, '0']
- [epy_block_0, PDU_out, pdu_pdu_to_tagged_stream_0, pdus]
- [mmse_resampler_xx_0, '0', osmosdr_sink_0, '0']
- [mmse_resampler_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [mmse_resampler_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [mmse_resampler_xx_0, '0', zeromq_pub_sink_0, '0']
- [mmse_resampler_xx_0_0, '0', blocks_throttle_0_0, '0']
- [mmse_resampler_xx_0_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [osmosdr_source_1, '0', mmse_resampler_xx_0_0, '0']
- [osmosdr_source_1, '0', qtgui_sink_x_0, '0']
- [osmosdr_source_1, '0', qtgui_waterfall_sink_x_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_0, '0', blocks_throttle_0, '0']
- [virtual_source_0_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [virtual_source_1, '0', digital_diff_decoder_bb_0, '0']
- [zeromq_sub_source_0, '0', mmse_resampler_xx_0_0, '0']
- [zeromq_sub_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
