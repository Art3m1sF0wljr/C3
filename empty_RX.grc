options:
  parameters:
    author: art3m1sf0wl
    generate_options: qt_gui
    id: empty_RX
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: '"bladerf=0,nchan=1,buffers=48,transfers=24,agc_mode=manual,biastee=1"'
    bb_gain0: '20'
    freq0: 415.4e6
    gain0: '50'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: '576000'
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [osmosdr_source_1, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
