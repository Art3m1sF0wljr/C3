options:
  parameters:
    generate_options: qt_gui
    id: test_0_yt
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: RX_rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: TX_rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: freq_slide
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: 1e3
    stop: 1e6
    value: '0'
  states: {}
- name: modulation_number
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-1'
    stop: '100'
    value: '0.5'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '10000'
    value: '440'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '529200'
  states: {}
- name: variablee
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '1000000'
    value: '44100'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Audio gain
    start: '0'
    step: '100e-3'
    stop: '100'
    value: '1.2'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: variablee
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '12'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/art3m1sf0wl/program/TRX_test/MonodyVocals.wav
    repeat: 'True'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 415.4e6+freq_slide
    gain0: TX_rf_gain
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: '"bladerf=0,nchan=1,buffers=48,transfers=24,agc_mode=manual"'
    bb_gain0: '20'
    freq0: 415.4e6
    gain0: RX_rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', osmosdr_sink_0, '0']
- [blocks_repeat_0, '0', blocks_float_to_complex_0, '0']
- [blocks_repeat_0, '0', hilbert_fc_0, '0']
- [blocks_wavfile_source_0, '0', blocks_repeat_0, '0']
- [hilbert_fc_0, '0', osmosdr_sink_0, '0']
- [osmosdr_source_1, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
