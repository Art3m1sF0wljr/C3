options:
  parameters:
    author: art3m1sf0wl
    generate_options: qt_gui
    id: my_test
    output_language: python
    title: my_test_continuous_wave
  states: {}

blocks:
- name: RX_rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: TX_rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: squelch_
  id: variable_qtgui_range
  parameters:
    start: '-100'
    step: '1'
    stop: '0'
    value: '-60'
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '1024'
    reference: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '96000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 200k
    offset: '0'
    phase: '0'
    samp_rate: 576k
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    comment: UP-Conversion -> 1MHz
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-200000.0'
    decim: '1'
    samp_rate: 576k
    taps: ' firdes.complex_band_pass(1, samp_rate, -samp_rate/100, samp_rate/100, 10000)'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '40000'
    decim: '1'
    gain: '1'
    samp_rate: '576000'
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    ant0: TX1
    args: '"bladerf=0,nchan=1,verbosity=verbose"'
    bb_gain0: '20'
    bw0: 576k
    comment: TX_freq => 437.5MHz
    freq0: 415.4e6
    gain0: '30'
    if_gain0: '20'
    sample_rate: '576000'
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: RX1
    args: '"bladerf=0,nchan=1,buffers=48,transfers=24,agc_mode=manual"'
    bb_gain0: '10'
    freq0: 415.4e6
    gain0: RX_rf_gain
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: 576k
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '96000'
    fc: '0'
    fftsize: '8192'
    name: after Xlating
    type: complex
    wintype: window.WIN_HANN
    ymin: '-150'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: 576k
    fc: '0'
    fftsize: '4096'
    name: '"RX spectrum"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_2_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 96k
    fc: '0'
    fftsize: '8192'
    name: TX - BB
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_2_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: 576e3
    fc: '0'
    fftsize: '8192'
    name: TX
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"Time Rx"'
    size: '1024'
    srate: 96k
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 576k
    fc: '0'
    fftsize: '1024'
    name: '"RX Waterfall"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: 576ksps to 96ksps
    decim: '6'
    fbw: '0.4'
    interp: '1'
    type: ccc
  states: {}

connections:
- [analog_feedforward_agc_cc_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_2_0, '0']
- [analog_sig_source_x_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_1, '1']
- [analog_simple_squelch_cc_0, '0', analog_feedforward_agc_cc_0, '0']
- [blocks_multiply_xx_0_1, '0', osmosdr_sink_0, '0']
- [blocks_multiply_xx_0_1, '0', qtgui_freq_sink_x_2_0_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0_1, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_1, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_simple_squelch_cc_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
